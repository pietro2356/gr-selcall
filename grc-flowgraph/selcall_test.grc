options:
  parameters:
    generate_options: qt_gui
    id: selcall_test
    output_language: python
    title: SelCal Flow Test
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sel_choser
  id: variable_qtgui_chooser
  parameters:
    label: Selective List
    label0: VVF1 - 85345
    label1: MSA1 - 18533
    label2: MSA2 - 18537
    label3: MSB1 - 19931
    label4: ELI1 - 18515
    num_opts: '5'
    option0: '85345'
    option1: '18533'
    option2: '18537'
    option3: '19931'
    option4: '18515'
    type: string
    value: '85345'
  states: {}
- name: sel_id
  id: variable_qtgui_entry
  parameters:
    label: Selective
    type: string
    value: sel_choser
  states: {}
- name: Sel_sender
  id: variable_qtgui_msg_push_button
  parameters:
    label: 'Send '
    msgName: pressed
    type: string
    value: sel_id
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    label: TX
    verticalalignment: '2'
  states: {}
- name: qtgui_ledindicator_0_0_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    label: RINGER LED
    verticalalignment: '2'
  states: {}
- name: selcall_selcall_decoder_0
  id: selcall_selcall_decoder
  parameters:
    code_length: '5'
    debug: 'False'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
    target_code: '18537'
    tone_duration_ms: '0.0'
  states: {}
- name: selcall_selcall_encoder_0
  id: selcall_selcall_encoder
  parameters:
    amplitude: '0.8'
    own_id: '11501'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
  states: {}
- name: selcall_selcall_ringer_0
  id: selcall_selcall_ringer
  parameters:
    amplitude: '0.5'
    duration: '5.0'
    sample_rate: audio_samp_rate
  states: {}

connections:
- [Sel_sender, pressed, selcall_selcall_encoder_0, msg_in]
- [selcall_selcall_decoder_0, '0', audio_sink_0_0, '0']
- [selcall_selcall_decoder_0, ringer, blocks_message_debug_0, log]
- [selcall_selcall_decoder_0, ringer, selcall_selcall_ringer_0, trigger]
- [selcall_selcall_decoder_0, selcall_out, blocks_message_debug_0, print]
- [selcall_selcall_encoder_0, '0', audio_sink_0, '0']
- [selcall_selcall_encoder_0, '0', selcall_selcall_decoder_0, '0']
- [selcall_selcall_encoder_0, ptt_out, qtgui_ledindicator_0, state]
- [selcall_selcall_ringer_0, '0', audio_sink_0_0_0, '0']
- [selcall_selcall_ringer_0, led, qtgui_ledindicator_0_0_0, state]

metadata:
  file_format: 1
  grc_version: 3.10.12.0

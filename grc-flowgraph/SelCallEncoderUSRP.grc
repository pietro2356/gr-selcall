options:
  parameters:
    author: pietro
    generate_options: qt_gui
    id: SelCallEncoderUSRP
    output_language: python
    title: SelCall Encoder USRP
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band
  id: variable
  parameters:
    value: int(25e2)
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: freq_ch
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    label0: PMR 10
    label1: PMR 11
    label2: PMR 12
    label3: PMR 4
    num_opts: '4'
    option0: '446118750'
    option1: '446131250'
    option2: '446143750'
    option3: '446043750'
    type: int
    value: '446043750'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: sel_choser
  id: variable_qtgui_chooser
  parameters:
    label: Selective List
    label0: VVF1 - 85345
    label1: MSA1 - 18533
    label2: MSA2 - 18537
    label3: MSB1 - 19931
    label4: ELI1 - 18515
    num_opts: '5'
    option0: '85345'
    option1: '18533'
    option2: '18537'
    option3: '19931'
    option4: '18515'
    type: string
    value: '85345'
  states: {}
- name: sel_id
  id: variable_qtgui_entry
  parameters:
    label: Selective
    type: string
    value: sel_choser
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: Sel_sender
  id: variable_qtgui_msg_push_button
  parameters:
    label: 'Send '
    msgName: pressed
    type: string
    value: sel_id
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(audio_samp_rate)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(audio_samp_rate)*10
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    label: Transmission status
    verticalalignment: '2'
  states: {}
- name: selcall_selcall_encoder_0
  id: selcall_selcall_encoder
  parameters:
    amplitude: '1'
    own_id: '18501'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_ch
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [Sel_sender, pressed, selcall_selcall_encoder_0, msg_in]
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0_0, '0']
- [selcall_selcall_encoder_0, '0', analog_nbfm_tx_0, '0']
- [selcall_selcall_encoder_0, '0', audio_sink_0, '0']
- [selcall_selcall_encoder_0, ptt_out, qtgui_ledindicator_0, state]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: 3.10.12.0

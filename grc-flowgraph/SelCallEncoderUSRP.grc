options:
  parameters:
    author: pietro
    generate_options: qt_gui
    id: SelCallEncoderUSRP
    output_language: python
    title: SelCall Encoder USRP
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band
  id: variable_qtgui_chooser
  parameters:
    label: Band
    label0: NB PMR 12.5k
    label1: NB VHF 12k
    label2: WB FM
    num_opts: '3'
    option0: int(25e2)
    option1: int(5e3)
    option2: int(38e3)
    type: int
    value: int(5e3)
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: freq_ch
  id: variable_qtgui_chooser
  parameters:
    label: Frequency
    label0: PMR 10
    label1: PMR 11
    label2: PMR 12
    label3: PMR 13
    num_opts: '4'
    option0: '446118750'
    option1: '446131250'
    option2: '446143750'
    option3: '446156250'
    type: int
    value: '446118750'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: sel_choser
  id: variable_qtgui_chooser
  parameters:
    label: Selective List
    label0: CO 118 T
    label1: MSA1 - T
    label2: MSA2 - T
    label3: MSB1 - CB
    label4: ELI1 - DD
    num_opts: '5'
    option0: '18501'
    option1: '18533'
    option2: '18537'
    option3: '19931'
    option4: '18515'
    type: string
    value: '18533'
  states: {}
- name: sel_id
  id: variable_qtgui_entry
  parameters:
    label: Selective
    type: string
    value: sel_choser
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: Sel_sender
  id: variable_qtgui_msg_push_button
  parameters:
    label: 'Send '
    msgName: pressed
    type: string
    value: sel_id
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(audio_samp_rate)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(audio_samp_rate)*10
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: band
    ctrlpanel: 'True'
    fc: freq_ch
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    label: TX
    verticalalignment: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: band
    fc: freq_ch
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: selcall_selcall_encoder_0
  id: selcall_selcall_encoder
  parameters:
    amplitude: '0.8'
    own_id: '11501'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_ch
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [Sel_sender, pressed, selcall_selcall_encoder_0, msg_in]
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0_0, '0']
- [selcall_selcall_encoder_0, '0', analog_nbfm_tx_0, '0']
- [selcall_selcall_encoder_0, '0', audio_sink_0, '0']
- [selcall_selcall_encoder_0, ptt_out, qtgui_ledindicator_0, state]
- [uhd_usrp_sink_0_0, async_msgs, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: 3.10.12.0

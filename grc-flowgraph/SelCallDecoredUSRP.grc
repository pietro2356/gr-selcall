options:
  parameters:
    author: pietro
    generate_options: qt_gui
    id: SelCallDecoredUSRP
    output_language: python
    title: SelCall Decored USRP
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band
  id: variable
  parameters:
    value: int(25e2)
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: freq_ch
  id: variable_qtgui_chooser
  parameters:
    label: Frequency
    label0: PMR 10
    label1: PMR 11
    label2: PMR 12
    label3: PMR 4
    num_opts: '4'
    option0: '446118750'
    option1: '446131250'
    option2: '446143750'
    option3: '446043750'
    type: int
    value: '446043750'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squelch
    start: '-150'
    step: '1'
    stop: '20'
    value: '-50'
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '50000'
    max_dev: band
    quad_rate: quadrature
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38e2
    low_cutoff_freq: '300'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    ctrlpanel: 'True'
    fc: freq_ch
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    label: Received Selective
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: fff
  states: {}
- name: selcal_selcall_decoder_0
  id: selcal_selcall_decoder
  parameters:
    code_length: '5'
    debug: 'False'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
    target_code: '85564'
    tone_duration_ms: '0.0'
  states: {}
- name: selcall_selcall_decoder_0
  id: selcall_selcall_decoder
  parameters:
    code_length: '5'
    debug: 'True'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
    target_code: '18533'
    tone_duration_ms: '0.0'
  states: {}
- name: selcall_selcall_ringer_0
  id: selcall_selcall_ringer
  parameters:
    amplitude: '0.5'
    duration: '5.0'
    sample_rate: audio_samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: band
    center_freq0: freq_ch
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', selcal_selcall_decoder_0, '0']
- [band_pass_filter_0, '0', selcall_selcall_decoder_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', band_pass_filter_0, '0']
- [selcal_selcall_decoder_0, '0', audio_sink_0, '0']
- [selcal_selcall_decoder_0, selcall_out, blocks_message_debug_0, print]
- [selcall_selcall_decoder_0, '0', audio_sink_0, '0']
- [selcall_selcall_decoder_0, ringer, selcall_selcall_ringer_0, trigger]
- [selcall_selcall_decoder_0, selcall_out, blocks_message_debug_0, print]
- [selcall_selcall_ringer_0, '0', audio_sink_0_1, '0']
- [selcall_selcall_ringer_0, led, qtgui_ledindicator_0, state]
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
